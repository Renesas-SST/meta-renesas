# Let handle modules respectively in our recipe

RDEPENDS:${PN}:remove = " \
    packagegroup-qt6-addons \
    packagegroup-qt6 \
"
