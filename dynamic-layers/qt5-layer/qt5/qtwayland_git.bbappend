# etnaviv mesa does not have glx
PACKAGECONFIG:remove = "xcomposite-glx"
