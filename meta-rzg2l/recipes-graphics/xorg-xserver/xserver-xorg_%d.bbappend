PACKAGECONFIG[glamor] = "--disable-glamor,--disable-glamor,libepoxy,libegl"
