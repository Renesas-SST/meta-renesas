PACKAGECONFIG:remove = "introspection"
EXTRA_OEMESON += "-Dintrospection=disabled"
