PACKAGECONFIG:append:class-target = " install-test-programs"
