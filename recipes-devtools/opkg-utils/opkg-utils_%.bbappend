FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://0001-update-alternatives-accept-quiet-as-a-no-op.patch"
